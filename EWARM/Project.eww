<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\16_ch_temp_module.ewp</path>
  </project>
  <batchBuild />
</workspace>
